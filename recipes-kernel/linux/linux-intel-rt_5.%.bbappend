FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI:append = " file://enable-tg3.cfg"