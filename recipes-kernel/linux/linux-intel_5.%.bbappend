require linux-atom-64.inc
