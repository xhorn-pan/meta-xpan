RDEPENDS:${PN}:remove = " \
	qtquickcontrols2 \
    	qtquickcontrols2-dev \
    	qtquickcontrols2-mkspecs \
	"
